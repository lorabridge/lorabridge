# IAR project modem.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L1XX_MD; CFG_lmic_clib; CFG_lmic_extra_apis; CFG_eu868; xxxCFG_us915; CFG_wimod_board; xxxCFG_sx1276mb1_board; CFG_sx1272_radio; xxxCFG_sx1276_radio
  ICCARM.CCDiagSuppress: Pa050,Pa089
  ICCARM.CCIncludePath2: ..\..\lmic; ..\..\stm32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: modem.hex
  ILINK.IlinkOutputFile: lmic.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CFG_lmic_clib; CFG_noassert
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: lmic.srec
  prebuild: cmd /c "$WS_DIR$/make.bat $WS_DIR$"
  group app
    ./: buffer.c frame.c hex.c main.c modem.c modem.h queue.c usart.c
  group lmic
    ../../lmic/: aes.c hal.h lmic.c lmic.h lorabase.h oslmic.c oslmic.h radio.c
  group stm32
    ../../stm32/: debug.c debug.h eeprom.c hal.c hw.c hw.h leds.c startup_stm32l1xx_md_iar.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
