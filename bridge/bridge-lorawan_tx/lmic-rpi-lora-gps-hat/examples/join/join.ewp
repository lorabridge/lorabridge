# IAR project join.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L1XX_MD; CFG_lmic_clib; CFG_eu868; CFG_wimod_board; CFG_sx1272_radio
  ICCARM.CCDiagSuppress: Pa050, Pa089
  ICCARM.CCIncludePath2: ..\..\lmic; ..\..\stm32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: join.hex
  ILINK.IlinkOutputFile: join.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group lmic
    ../../lmic/: aes.c hal.h lmic.c lmic.h lorabase.h oslmic.c oslmic.h radio.c
  group stm32
    ../../stm32/: debug.c debug.h hal.c hw.c hw.h startup_stm32l1xx_md_iar.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
